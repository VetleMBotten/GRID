## beacon/build_833/Kconfig/boards/Kconfig.nrf52dk
```kconfig
# Load board Kconfig descriptions.
osource "C:/ncs/v2.9.2/zephyr/boards/nordic/nrf52dk/Kconfig.nrf52dk"
```
